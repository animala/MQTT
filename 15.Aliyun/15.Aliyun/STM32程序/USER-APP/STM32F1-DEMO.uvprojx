# Keil uVision project STM32F1-DEMO.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1-DEMO +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_StdPeriph_Lib_V3.5.0\inc;..\USER-APP;..\USER-BSP;..\MALLOC;..\NETWORK;..\TLINK;..\ALINK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER-APP
    ./: main.c stm32f10x_it.c system_stm32f10x.c fy_includes.c
  group USER-BSP
    ../USER-BSP/: fy_led.c fy_systick.c fy_key.c fy_usart1.c fy_dma.c fy_timer4.c fy_beep.c fy_timer3.c fy_ntc.c fy_adc.c fy_oled12864.c fy_oledfont.c fy_spi.c fy_w25qxx.c fy_timer2.c fy_usart2.c
  group FWLIB
    ../STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group MALLOC
    ../MALLOC/: fy_malloc.c
  group NETWORK
    ../NETWORK/: fy_network.c fy_mqtt.c
  group TLINK
    ../TLINK/: fy_tlick.c
  group ALINK
    ../ALINK/: fy_alink.c
